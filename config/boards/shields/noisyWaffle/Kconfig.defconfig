## config/boards/shields/noisyWaffle/Kconfig.defconfig
```kconfig
if SHIELD_NOISYWAFFLE

config ZMK_KEYBOARD_NAME
    default "NoisyWaffle"

endif
```
